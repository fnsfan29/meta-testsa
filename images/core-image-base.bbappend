IMAGE_INSTALL_append = " helloworld sl pacman4console"
